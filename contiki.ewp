# IAR project contiki.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: CMSIS; StdPeriph_Driver\inc; User; contiki-2.5\core; contiki-2.5\core\sys; contiki-2.5\core\lib; contiki-2.5\cpu
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: contiki.srec
  ILINK.IlinkOutputFile: contiki.out
  ILINK.IlinkIcfFile: Linker\stm32f10x_flash
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group contiki
    contiki-2.5/core/: contiki-lib.h contiki-net.h contiki-version.h contiki.h
  group contiki/core/sys
    contiki-2.5/core/sys/: autostart.c etimer.c process.c procinit.c timer.c
  group contiki/cpu
    contiki-2.5/cpu/: clock.c debug-uart.c
  group platform/CMSIS
    CMSIS/: core_cm3.c stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group platform/StartUp
    StartUp/: startup_stm32f10x_md.s
  group platform/Stdperiph_Driver
    StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group platform/User
    User/: contiki-conf.h contiki-main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
